options:
  parameters:
    generate_options: no_gui
    id: fmDemod
    output_language: python
    title: Leanspace + GNU Radio
  states: {}

blocks:
- name: deframer_CRC16_Bool
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: deframer_CRC16
    section: deframer
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: deframer_G3RUH_Bool
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: deframer_G3RUH
    section: deframer
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: deframer_Short_Frames_Bool
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: deframer_Short_Frames
    section: deframer
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: deframer_Syncword_Threshold_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: deframer_Syncword_Threshold
    section: deframer
    type: int
    value: '4'
    writeback: None
  states: {}
- name: fileNameRaw
  id: variable
  parameters:
    value: main_Result_File_Prefix_Str + ".raw"
  states: {}
- name: fileNameRes
  id: variable
  parameters:
    value: main_Result_File_Prefix_Str + ".dat"
  states: {}
- name: freqOffset
  id: variable
  parameters:
    value: '11000'
  states: {}
- name: main_LPF_Cutoff_Freq_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: main_LPF_Cutoff_Freq
    section: main
    type: int
    value: sampRate - 10000
    writeback: None
  states: {}
- name: main_Network_Stream_Address_Str
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: main_Network_Stream_Address
    section: main
    type: string
    value: 127.0.0.1
    writeback: None
  states: {}
- name: main_Network_Stream_Port_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: main_Network_Stream_Port
    section: main
    type: int
    value: '8080'
    writeback: None
  states: {}
- name: main_Result_File_Prefix_Str
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: main_Result_File_Prefix
    section: main
    type: string
    value: ERROR_PREFIX
    writeback: None
  states: {}
- name: modulation_AFSK_Audio_Carrier_Freq_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_AFSK_Audio_Carrier_Freq
    section: modulation
    type: int
    value: '3600'
    writeback: None
  states: {}
- name: modulation_AFSK_Deviation_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_AFSK_Deviation
    section: modulation
    type: int
    value: '-1200'
    writeback: None
  states: {}
- name: modulation_BPSK_Differential_Bool
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_BPSK_Differential
    section: modulation
    type: bool
    value: 'True'
    writeback: None
  states: {}
- name: modulation_BPSK_Manchester_Bool
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_BPSK_Manchester
    section: modulation
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: modulation_Baud_Rate_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_Baud_Rate
    section: modulation
    type: int
    value: '9600'
    writeback: None
  states: {}
- name: modulation_Deframer_Type_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_Deframer_Type
    section: modulation
    type: int
    value: '6'
    writeback: None
  states: {}
- name: modulation_FSK_Sub_Audio_Bool
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_FSK_Sub_Audio
    section: modulation
    type: bool
    value: 'False'
    writeback: None
  states: {}
- name: modulation_Type_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: modulation_Type
    section: modulation
    type: int
    value: '3'
    writeback: None
  states: {}
- name: sampRate
  id: variable
  parameters:
    value: '480000'
  states: {}
- name: sdr_BB_Gain_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: sdr_BB_Gain
    section: sdr
    type: int
    value: '40'
    writeback: None
  states: {}
- name: sdr_Freq_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: sdr_Freq
    section: sdr
    type: int
    value: '103600000'
    writeback: None
  states: {}
- name: sdr_IF_Gain_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: sdr_IF_Gain
    section: sdr
    type: int
    value: '40'
    writeback: None
  states: {}
- name: sdr_LNA_Gain_Int
  id: variable_config
  parameters:
    config_file: /home/stanislavb/sdr_prototypes/master/default
    option: sdr_LNA_Gain
    section: sdr
    type: int
    value: '14'
    writeback: None
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '10'
    audio_pass: '2400'
    audio_stop: '3400'
    chan_rate: sampRate
    deviation: '17000'
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: fileNameRes
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: fileNameRaw
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: data
    type: byte
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: Modulation
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '4'
    output_index: modulation_Type_Int
    type: complex
  states: {}
- name: blocks_selector_1
  id: blocks_selector
  parameters:
    comment: For debugging purposes
    enabled: 'True'
    input_index: '0'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_2
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: modulation_Type_Int
    num_inputs: '4'
    num_outputs: '7'
    output_index: modulation_Deframer_Type_Int
    type: float
  states: {}
- name: blocks_selector_3
  id: blocks_selector
  parameters:
    comment: DC blocker bypass
    enabled: 'True'
    input_index: '1'
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_4
  id: blocks_selector
  parameters:
    comment: |-
      if modulation != FM

      1 if modulation_Type_Int != 3 else 0
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: '1'
    type: complex
  states: {}
- name: blocks_udp_sink_0
  id: blocks_udp_sink
  parameters:
    eof: 'True'
    ipaddr: main_Network_Stream_Address_Str
    port: main_Network_Stream_Port_Int
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: fileNameRes
    samp_rate: int(sampRate / 10)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/stanislavb/satellite-recordings/gomx_1.wav
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: '(modulation != FM) ? 10 : 1'
    cutoff_freq: main_LPF_Cutoff_Freq_Int
    decim: 10 if modulation_Type_Int != 3 else 1
    gain: '1'
    samp_rate: sampRate
    type: fir_filter_ccf
    width: '3000'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: File names config
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: SDR config
  states: {}
- name: note_1
  id: note
  parameters:
    note: Modulation config
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Deframing config
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: Network config
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: sdr_BB_Gain_Int
    dc_offset_mode0: '2'
    freq0: sdr_Freq_Int
    gain0: sdr_LNA_Gain_Int
    gain_mode0: 'False'
    if_gain0: sdr_IF_Gain_Int
    iq_balance_mode0: '2'
    sample_rate: sampRate
    sync: sync
    type: fc32
  states: {}
- name: satellites_afsk_demodulator_0
  id: satellites_afsk_demodulator
  parameters:
    af_carrier: modulation_AFSK_Audio_Carrier_Freq_Int
    baudrate: modulation_Baud_Rate_Int
    deviation: modulation_AFSK_Deviation_Int
    iq: 'True'
    samp_rate: sampRate / 10
  states: {}
- name: satellites_ao40_fec_deframer_0
  id: satellites_ao40_fec_deframer
  parameters:
    crc: deframer_CRC16_Bool
    short_frames: deframer_Short_Frames_Bool
    threshold: deframer_Syncword_Threshold_Int
  states: {}
- name: satellites_ax100_deframer_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"RS"'
    threshold: deframer_Syncword_Threshold_Int
  states: {}
- name: satellites_ax100_deframer_0_0
  id: satellites_ax100_deframer
  parameters:
    mode: '"ASM"'
    scrambler: '"CCSDS"'
    threshold: deframer_Syncword_Threshold_Int
  states: {}
- name: satellites_ax25_deframer_1
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: deframer_G3RUH_Bool
  states: {}
- name: satellites_bpsk_demodulator_0
  id: satellites_bpsk_demodulator
  parameters:
    baudrate: modulation_Baud_Rate_Int
    differential: modulation_BPSK_Differential_Bool
    f_offset: freqOffset
    iq: 'True'
    manchester: modulation_BPSK_Manchester_Bool
    samp_rate: sampRate / 10
  states: {}
- name: satellites_fossasat_deframer_0
  id: satellites_fossasat_deframer
  parameters:
    threshold: deframer_Syncword_Threshold_Int
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: modulation_Baud_Rate_Int
    iq: 'True'
    samp_rate: sampRate / 10
    subaudio: modulation_FSK_Sub_Audio_Bool
  states: {}
- name: satellites_u482c_deframer_0
  id: satellites_u482c_deframer
  parameters:
    threshold: deframer_Syncword_Threshold_Int
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bpskRaw
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: afskRaw
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: fskRaw
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: debug
  states: {}
- name: virtual_sink_6
  id: virtual_sink
  parameters:
    stream_id: analogFM
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bpskRaw
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: afskRaw
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: fskRaw
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: debug
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: analogFM
  states: {}
- name: xmlrpc_server_0
  id: xmlrpc_server
  parameters:
    addr: localhost
    comment: |-
      Doppler compensation

      Receives an updated frequency
      Update from GSC through XMLRPC
    port: '7777'
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_selector_2, '3']
- [blocks_float_to_complex_0, '0', blocks_selector_1, '1']
- [blocks_null_source_1, '0', blocks_float_to_complex_0, '1']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_udp_sink_0, '0']
- [blocks_selector_0, '0', virtual_sink_0, '0']
- [blocks_selector_0, '1', virtual_sink_1, '0']
- [blocks_selector_0, '2', virtual_sink_2, '0']
- [blocks_selector_0, '3', virtual_sink_6, '0']
- [blocks_selector_1, '0', blocks_selector_0, '0']
- [blocks_selector_2, '0', satellites_ao40_fec_deframer_0, '0']
- [blocks_selector_2, '1', satellites_u482c_deframer_0, '0']
- [blocks_selector_2, '2', satellites_ax25_deframer_1, '0']
- [blocks_selector_2, '3', satellites_fossasat_deframer_0, '0']
- [blocks_selector_2, '4', satellites_ax100_deframer_0, '0']
- [blocks_selector_2, '5', satellites_ax100_deframer_0_0, '0']
- [blocks_selector_2, '6', blocks_wavfile_sink_0, '0']
- [blocks_selector_3, '0', low_pass_filter_1, '0']
- [blocks_selector_4, '0', blocks_null_sink_0, '0']
- [blocks_selector_4, '1', blocks_file_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [dc_blocker_xx_0, '0', blocks_selector_3, '1']
- [low_pass_filter_1, '0', blocks_selector_1, '0']
- [low_pass_filter_1, '0', blocks_selector_4, '0']
- [osmosdr_source_0, '0', blocks_selector_3, '0']
- [osmosdr_source_0, '0', dc_blocker_xx_0, '0']
- [satellites_afsk_demodulator_0, '0', blocks_selector_2, '1']
- [satellites_ao40_fec_deframer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ao40_fec_deframer_0, out, virtual_sink_3, '0']
- [satellites_ax100_deframer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ax100_deframer_0, out, virtual_sink_3, '0']
- [satellites_ax100_deframer_0_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ax100_deframer_0_0, out, virtual_sink_3, '0']
- [satellites_ax25_deframer_1, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_ax25_deframer_1, out, virtual_sink_3, '0']
- [satellites_bpsk_demodulator_0, '0', blocks_selector_2, '0']
- [satellites_fossasat_deframer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_fossasat_deframer_0, out, virtual_sink_3, '0']
- [satellites_fsk_demodulator_0, '0', blocks_selector_2, '2']
- [satellites_u482c_deframer_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [satellites_u482c_deframer_0, out, virtual_sink_3, '0']
- [virtual_source_0, '0', satellites_bpsk_demodulator_0, '0']
- [virtual_source_1, '0', satellites_afsk_demodulator_0, '0']
- [virtual_source_2, '0', satellites_fsk_demodulator_0, '0']
- [virtual_source_5, '0', blocks_message_debug_0, print_pdu]
- [virtual_source_6, '0', analog_fm_demod_cf_0, '0']

metadata:
  file_format: 1
